# Keil uVision project Template_1.uvprojx, settings and files
target Template (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  AfterMake: fromelf --bin --output ..\YXG_V4.1.0.bin ..\OBJ\Template.axf
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;.\app;..\APP;..\DRIVE\led;..\DRIVE\motor;..\DRIVE\signal;..\DRIVE\usart;..\SYSTEM\delay;..\SYSTEM\malloc;..\SYSTEM\sys;..\SYSTEM\system;..\SYSTEM\time;..\SYSTEM\stmflash;..\SYSTEM\iap;..\DRIVE\lift;..\DRIVE\cryogen;..\CLOUD_PROTOCOL\protocol;..\DEV_PROTOCOL;..\CLOUD_PROTOCOL\Json;..\SYSTEM\md5;..\CAN_BUS;..\DRIVE\speedmotor;..\DRIVE\gate;..\TEST;..\CLOUD_PROTOCOL\mqtt;..\CLOUD_PROTOCOL\mqtt;..\CLOUD_PROTOCOL\http;..\CLOUD_PROTOCOL\ota;..\DRIVE\rtc;..\SYSTEM\watchdog;..\SYSTEM\debug;..\DRIVE\elc_lock;..\APP;..\DRIVE\speedmotor;..\CAN_MASTER_DRIVE;..\DEV_SALVE_DRIVE;..\DRIVE\misc;..\CLOUD_PROTOCOL\mqtt_v1.0;..\CLOUD_PROTOCOL\http;..\CLOUD_PROTOCOL\Json;..\CLOUD_PROTOCOL\protocol;..\CLOUD_PROTOCOL\ota;..\DGUS;..\DRIVE\rtc;..\CLOUD_PROTOCOL\format;..\DRIVE\ir
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_bkp.c stm32f10x_dma.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_rtc.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/time/: timer.c
    ../SYSTEM/system/: task_manage.c system.c
    ../SYSTEM/malloc/: sys_malloc.c
    ../SYSTEM/stmflash/: stmflash.c
    ../SYSTEM/watchdog/: watchdog.c
  group DRIVE
    ../DRIVE/signal/: analog_signal.c digital_signal.c sensor.c signal_gpio.c signal_scan.c
    ../DRIVE/ir/: ir.c
