# Keil uVision project Template.uvprojx, settings and files
target Template (ARM-ADS)
  device: STM32F103VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  AfterMake: fromelf --bin --output ..\BootLoad_V1.2.2.bin ..\OBJ\Template.axf
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;.\app;..\CAN_BUS;..\APP;..\DRIVE\led;..\DRIVE\motor;..\DRIVE\signal;..\DRIVE\usart;..\SYSTEM\delay;..\SYSTEM\malloc;..\SYSTEM\sys;..\SYSTEM\system;..\SYSTEM\time;..\SYSTEM\stmflash;..\SYSTEM\iap;..\DRIVE\cryogen
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c stm32f10x_adc.c
  group SYSTEM
    ../SYSTEM/iap/: iap.c
    ../SYSTEM/stmflash/: stmflash.c
    ../SYSTEM/sys/: sys.c
