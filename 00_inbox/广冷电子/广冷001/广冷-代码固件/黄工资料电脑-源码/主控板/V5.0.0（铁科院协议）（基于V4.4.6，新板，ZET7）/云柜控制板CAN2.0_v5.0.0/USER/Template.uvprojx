# Keil uVision project Template.uvprojx, settings and files
target Template (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  AfterMake: fromelf --bin --output ..\YXG_V4.1.0.bin ..\OBJ\Template.axf
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;.\app;..\APP;..\DRIVE\led;..\DRIVE\motor;..\DRIVE\signal;..\DRIVE\usart;..\SYSTEM\delay;..\SYSTEM\malloc;..\SYSTEM\sys;..\SYSTEM\system;..\SYSTEM\time;..\SYSTEM\stmflash;..\SYSTEM\iap;..\DRIVE\lift;..\DRIVE\cryogen;..\CLOUD_PROTOCOL\protocol;..\DEV_PROTOCOL;..\CLOUD_PROTOCOL\Json;..\SYSTEM\md5;..\CAN_BUS;..\DRIVE\speedmotor;..\DRIVE\gate;..\TEST;..\CLOUD_PROTOCOL\mqtt;..\CLOUD_PROTOCOL\mqtt;..\CLOUD_PROTOCOL\http;..\CLOUD_PROTOCOL\ota;..\DRIVE\rtc;..\SYSTEM\watchdog;..\SYSTEM\debug;..\DRIVE\elc_lock;..\APP;..\DRIVE\speedmotor;..\CAN_MASTER_DRIVE;..\DEV_SALVE_DRIVE;..\DRIVE\misc;..\CLOUD_PROTOCOL\mqtt_v1.0;..\CLOUD_PROTOCOL\http;..\CLOUD_PROTOCOL\Json;..\CLOUD_PROTOCOL\protocol;..\CLOUD_PROTOCOL\ota;..\DGUS;..\DRIVE\rtc;..\CLOUD_PROTOCOL\format
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_bkp.c stm32f10x_dma.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_rtc.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/time/: timer.c
    ../SYSTEM/system/: task_manage.c system.c
    ../SYSTEM/malloc/: sys_malloc.c
    ../SYSTEM/iap/: iap.c
    ../SYSTEM/stmflash/: stmflash.c
    ../SYSTEM/debug/: debug.c
    ../SYSTEM/md5/: md5.c
    ../SYSTEM/watchdog/: watchdog.c
  group APP
    ../APP/: sell_app.c tempcontrol.c sys_config.c sell_history.c sellmotor.c
  group DRIVE
    ../DRIVE/motor/: motor_drive.c motor_gpio.c motor_test.c
    ../DRIVE/signal/: analog_signal.c digital_signal.c sensor.c signal_gpio.c signal_scan.c
    ../DRIVE/cryogen/: compressor_control.c cryogen_drive.c
    ../DRIVE/led/: led.c
    ../DRIVE/elc_lock/: elc_lock.c
    ../DRIVE/speedmotor/: basic_gate_motor.c speed_motor_gpio.c
    ../DRIVE/misc/: misc_gpio.c
    ../DRIVE/rtc/: rtc.c
  group DEV_PROTOCOL
    ../DRIVE/usart/: usart.c
  group CAN_MASTER_DRIVE
    ../CAN_MASTER_DRIVE/: misc_control.c
  group DEV_SALVE_DRIVE
    ../DEV_SALVE_DRIVE/: miscs.c
  group CLOUD_PROTOCOL
    ../CLOUD_PROTOCOL/protocol/: NetworkModule.c at_ec20.c cloud_protocol.c wireless_hardware_interface.c wireless_module_init.c esp32.c
    ../CLOUD_PROTOCOL/Json/: cJSON.c
    ../CLOUD_PROTOCOL/format/: format.c
  group MQTT_V1.0
    ../CLOUD_PROTOCOL/mqtt_v1.0/: mqtt_config.c mqtt_connect.c mqtt_packet.c mqtt_qos1.c mqtt_recive.c mqtt_send.c time_stamp.c mqtt_ota_if.c
  group DGUS
    ../DGUS/: dgus_recive.c dgus_send.c dgus_crc16.c dgus_app.c dgus_control.c
